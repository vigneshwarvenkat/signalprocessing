<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>chat_app</value></param>
<param><key>author</key><value>Martin Braun</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A chat app that uses message passing</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>MessagePassingChatApp</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>Interference</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>grid_pos</key><value>(2, 20, 1, 5)</value></param>
<param><key>label</key><value>Enable Interference</value></param>
<param><key>true</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1.2</value></param>
<param><key>grid_pos</key><value>(4, 1, 1, 10)</value></param>
<param><key>label</key><value>Carrier Frequency (GHz)</value></param>
<param><key>max</key><value>1.7</value></param>
<param><key>min</key><value>0.1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>int(fc*1000000000)</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>fsym</value></param>
<param><key>choices</key><value>[80, 100, 160, 200, 320, 400]</value></param>
<param><key>value</key><value>200</value></param>
<param><key>grid_pos</key><value>(4,12, 1, 5)</value></param>
<param><key>label</key><value>Symbol Rate (Symbols per second)</value></param>
<param><key>labels</key><value>["80k", "100k", "160k", "200k", "320k", "400k"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>int(samp_rate/(fsym*1000))</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>msg_str</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Hello"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,1,3,18)</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>preamble</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"1000000101010101"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Preamble</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>preambleOut</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"1000000101010101"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Preamble Output</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1600000</value></param>
</block>
<block>
<key>EE2033_ook_text_b_sink</key>
<param><key>id</key><value>EE2033_ook_text_b_sink_0</value></param>
<param><key>data_rate</key><value>fsym*1000</value></param>
<param><key>matched_text</key><value>msg_str</value></param>
<param><key>preamble</key><value>preambleOut</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>300e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>20e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>300e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>100e3</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>EE2033_ook_text_b_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
